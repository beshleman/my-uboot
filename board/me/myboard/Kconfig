## board/me/myboard/Kconfig
```kconfig
if TARGET_MYBOARD

config SYS_BOARD
	default "myboard"

config SYS_VENDOR
	default "me"

config SYS_CONFIG_NAME
	default "myboard"

endif
```
